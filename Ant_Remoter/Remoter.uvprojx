# Keil uVision project Remoter.uvprojx, settings and files
target Remoter_V1.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ANO_USB +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: .\Driver;.\STM32_LIB\CMSIS;.\USB_hid;.\USB_library;.\STM32_LIB\LIB\inc;.\SYSTEM\sys;.\SYSTEM\delay;.\SYSTEM\usart;.\Remoter
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Remoter
    ./Remoter/: main.c Stick.c
  group Driver
    ./Driver/: KEY.c LED.c Nrf24l01.c Oled.c stm32f10x_it.c ADC.c SPI1.c exti.c
  group LIB
    ./STM32_LIB/CMSIS/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c core_cm3.c
    ./STM32_LIB/LIB/src/: stm32f10x_rcc.c misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c
    ./STM32_LIB/LIB/inc/: stm32f10x_conf.h
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
  group README
    ./README/: readme.txt
software components: CMSIS:CORE 5.0.1
