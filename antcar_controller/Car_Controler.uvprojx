# Keil uVision project Car_Controler.uvprojx, settings and files
target Car_Controler (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Car_Controler +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/Car_Controler.bin ./Objects/Car_Controler.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\USER;.\STM32F10x_FWLib\inc;.\HARDWARE\bsp_init;.\HARDWARE;.\HARDWARE\bsp_remote;.\HARDWARE\bsp_wheel_motor;.\SYSTEM\protocal;.\SYSTEM\SysTick;.\HARDWARE\bsp_battery_adc;.\HARDWARE\bsp_box_motor_timer;.\SYSTEM\watchdog;.\HARDWARE\bsp_led;.\HARDWARE\bsp_trail;.\HARDWARE\bsp_anti_col;.\SYSTEM\system_timer;.\HARDWARE\bsp_eeprom_i2c;.\SYSTEM\FaultProcess;.\HARDWARE\bsp_CCD_ADC;.\HARDWARE\bsp_sdio;.\HARDWARE\bsp_WheelMotor_CAN;.\FATFS;.\FATFS\option;.\SYSTEM\debug;.\HARDWARE\bsp_OldMotor_CAN;.\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ./HARDWARE/bsp_init/: bsp_init.c
    ./HARDWARE/bsp_wheel_motor/: bsp_wheel_motor.c
    ./HARDWARE/bsp_remote/: bsp_remote.c
    ./HARDWARE/bsp_battery_adc/: bsp_battery_adc.c
    ./HARDWARE/bsp_box_motor_timer/: bsp_box_motor_timer.c
    ./HARDWARE/bsp_led/: bsp_led.c
    ./HARDWARE/bsp_trail/: bsp_trail.c
    ./HARDWARE/bsp_anti_col/: bsp_anti_col.c
    ./HARDWARE/bsp_eeprom_i2c/: bsp_eeprom_i2c.c
    ./HARDWARE/bsp_CCD_ADC/: bsp_CCD_ADC.C
    ./HARDWARE/bsp_WheelMotor_CAN/: bsp_WheelMotor_CAN.c
    ./HARDWARE/bsp_sdio/: bsp_sdio_sdcard.c sdio_test.c
    ./HARDWARE/bsp_OldMotor_CAN/: bsp_OldMotor_CAN.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ./SYSTEM/protocal/: protocal.c
    ./SYSTEM/SysTick/: SysTick.c
    ./SYSTEM/watchdog/: watchdog.c
    ./SYSTEM/system_timer/: system_timer.c
    ./SYSTEM/FaultProcess/: FaultProcess.c
    ./SYSTEM/debug/: debug.c
  group FATFS
    ./FATFS/: diskio.c ff.c FileReadWrite.c
    ./FATFS/option/: cc936.c
