# Keil uVision project CANSlave.uvprojx, settings and files
target CANSlave (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CANSlave +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\TIME;..\HARDWARE\LED;..\HARDWARE\CAN;..\HARDWARE\E2PROM_I2C;..\SYSTEM;..\HARDWARE\BoxMoter;..\HARDWARE\CCD;..\HARDWARE\BSP;..\HARDWARE\Bumper;..\SYSTEM\watchdog;..\HARDWARE\EXPANDBOARD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIME/: sys_time.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/E2PROM_I2C/: eeprom_i2c.c
    ../HARDWARE/BoxMoter/: boxmoter.c
    ../HARDWARE/CCD/: ccd.c
    ../HARDWARE/BSP/: bsp_init.c
    ../HARDWARE/Bumper/: bumper.c
    ../HARDWARE/EXPANDBOARD/: expandboard.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/watchdog/: watchdog.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_can.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
